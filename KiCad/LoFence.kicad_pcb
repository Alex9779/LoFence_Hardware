# Repository Alex9779/LoFence_Hardware

File README.md:

# LoFence V2 Hardware

The LoFence V2 PCB is designed with KiCad.

The BOM has been optimized for being produced and assembled by [JLCPCB](https://jlcpcb.com/). Even the THT components except the big resistors everything should be available there. Disregarding the LA66 module which is not doable in a non-bulk production.

I use the "Fabrication Toolkit" plugin for KiCad aka [JLC-Plugin-for-KiCad](https://github.com/bennymeg/JLC-Plugin-for-KiCad) to one-click export production files.

To complete the PCB you need:

- 2 x 10M resistor rated for 10kV (e.g. Vishay *VR68000001005JAC00* from [tme.eu](https://www.tme.eu/details/vr68000001005jac00/tht-resistors/vishay/))
- 1 x 1M resistor rated for 100V (e.g. Royal Ohm *MGR0W4F1004A10* from [tme.eu](https://www.tme.eu/details/mgr0.25w-1m/tht-resistors/royal-ohm/mgr0w4f1004a10/))
- 1 x [Dragino LA66 module](https://www.dragino.com/products/lora/item/230-la66-lorawan-module.html) for your LoRaWAN frequency band

And to complete a device:

- 1 x [Gainta *G368MF*](https://www.gainta.com/en/g368mf.html) case (e.g. from [tme.eu](https://www.tme.eu/details/g368mf/multipurpose-enclosures/gainta/))
- 4 x 2.9x6.5mm plastic screw (e.g. from [tme.eu](https://www.tme.eu/details/b2.9x6.5_bn14065/screws/bossard/2097273/))
- 1 x double banana socket or any connectors you want to use for positive and negative fence connection (e.g. this from [tme.eu](https://www.tme.eu/details/bc-119/4mm-banana-sockets/sci/)) or similar
- 2 x 40mm wire 1.5mm^2 with M5 cable lugs to connect the PCB with the banana socket (this is what I use)
- 1 x antenna suitable for your LoRaWAN frequency (I get them from Aliexpress)
- \>=50mm antenna cable from IPEX to whatever connector your antenna has (I use 50mm ordered from Aliexpress and normal SMA)

How to program the firmware is described in the [firmware repository](https://github.com/Alex9779/LoFence_Firmware).

## KiCad design KiCad/LoFence.kicad_pcb

Parts:
B10, B11, B20, B21: MY-18650-01; JLCPCB Position Offset -3.8,0
B31, B41: MY-18650-01; JLCPCB Position Offset -3.8,0; not fitted
BT1: Battery_Cell; 18500HolderSMD_x2_BeilaMoo
C1, C2, C3: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7, C8, C9, C10, C11, C12, C13: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: SS54; D_SMA_Handsoldering
D2, D3: BAV70; SOT-23; JLCPCB Part # C68978
J1: Fence+; TestPoint_THTPad_4.0x4.0mm_Drill2.0mm
J2: Fence-; TestPoint_THTPad_4.0x4.0mm_Drill2.0mm
L1: 1.5uH; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder
MH1, MH2, MH3, MH4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
Q1: LBSS84LT1G; SOT-23; JLCPCB Part # C8492
Q2: 2N7002; SOT-23; JLCPCB Rotation Offset 180
R1, R4: 10M 10KV; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal; JLCPCB Position Offset 10,0
R2: 1M 700V; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; JLCPCB Part # C18816311
R3: 5k6; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6, R7, R9, R10, R12, R13, R14, R17: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R15, R18: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 47R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; TS-1187A-B-A-B; JLCPCB Part # C318884
SW2: ACTIVATE; TS-1187A-B-A-B; JLCPCB Part # C318884
U1: TPS63051RMW; JLCPCB Part # C139412
U2: TLV9062; SOIC-8_3.9x4.9mm_P1.27mm; JLCPCB Part # C398355
U3: ATmega328PB-AU; TQFP-32_7x7mm_P0.8mm; JLCPCB Part # C132230
U4: LA66; LA66_serial-only
Y1: 32768 Hz; Crystal_SMD_3215-2Pin_3.2x1.5mm; JLCPCB Part # C32346

Connections:
+3V3: C1.1, C2.1, C7.2, C11.2, R7.1, R8.1, R16.1, U1.4 (VOUT), U1.5 (FB), U3.4 (VCC), U4.29 (VCC), U4.32 (VCC), U4.33 (VCC), U4.52 (VCC), U4.53 (VCC); also elsewhere on the board
ACTIVATE: Q2.1 (G), R18.1, U3.26 (PC3)
ADC_NEG: C9.1, D3.3 (K), R12.1, R15.2, U3.23 (PC0)
ADC_POS: C6.1, D2.3 (K), R10.1, R11.2, U3.25 (PC2)
ADC_POWER: C10.1, U2.8 (V+), U3.24 (PC1)
AVCC: C12.2, R16.2, U3.18 (AVCC)
BAT_ADC: R5.1, R6.2, U3.27 (PC4)
BAT_GND: R6.1, U3.28 (PC5)
BAT_VCC: C13.1, D1.1 (K), Q1.2 (S), R5.2, R17.2
GND: B10.1, B20.1, BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.1, C12.1, Q2.2 (S), R3.1, R4.2, R11.1, R14.1, R15.1, R18.2, SW1.2, SW2.2, U1.2 (GND), U1.6 (PFM/PWM), U1.9 (GND), U2.4 (V-), U3.5 (GND), U3.21 (GND), U4.3 (GND), U4.31 (GND), U4.47 (GND), U4.48 (GND), U4.50 (GND), U4.54 (GND), U4.55 (GND), U4.58 (GND), U4.59 (GND), U4.61 (GND), U4.62 (GND); also elsewhere on the board
LA_BOOT: U4.8 (PA2); also elsewhere on the board
LA_RESET: U3.13 (PB1), U4.26 (RSTN); also elsewhere on the board
LA_RX: U3.31 (PD1), U4.34 (RXD); also elsewhere on the board
LA_TX: U3.30 (PD0), U4.35 (TXD); also elsewhere on the board
LED_CLK: U3.12 (PB0); also elsewhere on the board
LED_IDLE: U3.11 (PD7); also elsewhere on the board
LED_MSR: U3.10 (PD6); also elsewhere on the board
LED_TX: U3.9 (PD5); also elsewhere on the board
MCU_MISO: U3.16 (PB4); also elsewhere on the board
MCU_MOSI: U3.15 (PB3); also elsewhere on the board
MCU_RESET: C5.1, R8.2, SW1.1, U3.29 (~RESET/PC6); also elsewhere on the board
MCU_SCK: U3.17 (PB5); also elsewhere on the board
unnamed: B11.1, B21.1, B31.1, B41.1, BT1.1 (+), D1.2 (A)
unnamed: D2.1 (A1), D2.2 (A2), U2.7
unnamed: D3.1 (A1), D3.2 (A2), U2.1
unnamed: J1.1, R1.2
unnamed: J2.1, R4.1
unnamed 33: C13.2, Q1.1 (G), Q2.3 (D), R17.1, SW2.1; also elsewhere on the board
unnamed: R1.1, R2.2
unnamed: L1.1, U1.1 (L1)
unnamed: L1.2, U1.3 (L2)
unnamed: R7.2, U1.8 (PG)
unnamed: C4.1, U1.7 (SS)
unnamed: R14.2, U2.3 (+)
unnamed: R12.2, R13.1, U2.2 (-)
unnamed: R9.1, U2.5 (+)
unnamed: R10.2, U2.6 (-)
unnamed: C8.1, U3.20 (AREF)
unnamed: U3.7 (XTAL1/PB6), Y1.1
unnamed: U3.8 (XTAL2/PB7), Y1.2
PM_VCC: C3.1, Q1.3 (D), U1.10 (ILIM0), U1.11 (EN), U1.12 (VIN)
PROBE: R2.1, R3.2, R9.2, R13.2

Notes on the sheet:
R3 options for maximum measurable fence voltage: 12.0kV --> 5k49 11.8kV --> 5k6 (default) 9.5kV --> 6k98 7.6kV --> 8k66 6.0kV --> 11k
Power Supply
Battery Monitor
AMP+
MCU
Mechanics
MCU Reset
Activation
Power OpAmp
LoRa
Probe
Amp-

Parts:
D4, D6: EMERALD; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; JLCPCB Part # C2297
D5, D7: YELLOW; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; JLCPCB Part # C2296
D8: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; JLCPCB Part # C84256
J3: ISP; PinHeader_2x03_P2.54mm_Vertical; JLCPCB Position Offset -2.54,-1.27
J4: DEBUG LED; PinHeader_1x03_P2.54mm_Vertical; JLCPCB Position Offset -2.54,0
J5: DEBUG MCU; PinHeader_1x04_P2.54mm_Vertical; not fitted
J6: DEBUG LA; PinHeader_1x04_P2.54mm_Vertical; not fitted
J7: FLASH LA; PinHeader_1x04_P2.54mm_Vertical; not fitted
R19, R21: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R20, R22: 220R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23: 150R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+3V3: J3.2, J5.1, J6.1, R19.2; also elsewhere on the board
GND: J3.6, J4.2, J5.4, J6.4, J7.4; also elsewhere on the board
LA_BOOT: J7.1; also elsewhere on the board
LA_RESET: J7.3; also elsewhere on the board
LA_RX: J6.2, J7.2; also elsewhere on the board
LA_TX: J6.3; also elsewhere on the board
LED_CLK: R20.2; also elsewhere on the board
LED_IDLE: R21.2; also elsewhere on the board
LED_MSR: R22.2; also elsewhere on the board
LED_TX: R23.2; also elsewhere on the board
MCU_MISO: J3.1, J5.2; also elsewhere on the board
MCU_MOSI: J3.4, J5.3; also elsewhere on the board
MCU_RESET: J3.5; also elsewhere on the board
MCU_SCK: J3.3; also elsewhere on the board
unnamed: D4.2 (A), R19.1
unnamed 26: D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), J4.1; also elsewhere on the board
unnamed: D5.2 (A), R20.1
unnamed: D6.2 (A), R21.1
unnamed: D7.2 (A), R22.1
unnamed: D8.2 (A), R23.1

Notes on the sheet:
Conn Flash LA
Conn Debug MCU
Conn Debug LA
Conn ISP
LED Debug

Board: 2 copper layers, 72.0 x 133.0 mm, 71 parts (0 on the bottom side), 48 nets.

Other parts of the board:
locked: DEBUG LED; PinHeader_1x03_P2.54mm_Vertical
locked#2, locked#3: locked; TS-1187A-B-A-B

Their connections:
GND: locked.2, locked#2.2, locked#3.2; also elsewhere on the board
MCU_RESET: locked#2.1; also elsewhere on the board
unnamed 26: locked.1; also elsewhere on the board
unnamed 33: locked#3.1; also elsewhere on the board

## KiCad design lofence.kicad_pcb

Board: 2 copper layers, 72.0 x 138.0 mm, 58 parts (0 on the bottom side), 43 nets.

Parts:
BT1, BT2: Battery_Cell; 18500HolderSMD
C1, C2, C3: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 1nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C6, C7, C8, C9, C10, C11, C12: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: BAV70LT; SOT-23
D3, D5: EMERALD; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D4, D6: YELLOW; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D7: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: DEBUG LED; PinHeader_1x03_P2.54mm_Vertical
J2: ISP; PinHeader_2x03_P2.54mm_Vertical
J3: DEBUG MCU; PinHeader_1x04_P2.54mm_Vertical
J4: DEBUG LA; PinHeader_1x04_P2.54mm_Vertical
J101: Fence+; TestPoint_THTPad_4.0x4.0mm_Drill2.0mm
J102: Fence-; TestPoint_THTPad_4.0x4.0mm_Drill2.0mm
L1: 1.5uH; L_1008_2520Metric_Pad1.43x2.20mm_HandSolder
MH1, MH2, MH3: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
R1, R4: 10M 10KV; R_Axial_DIN0516_L15.5mm_D5.0mm_P20.32mm_Horizontal
R2: 1M 700V; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 5k76; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6: 232R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R9, R10, R12, R13, R14: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R15: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 47R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18, R19, R20: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21: 68R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; SW_SPST_B3SL-1002P
U1: TPS63051RMW
U2: TLV9062; SOIC-8_3.9x4.9mm_P1.27mm
U3: ATmega328PB-AU; TQFP-32_7x7mm_P0.8mm
U4: LA66; LA66_serial-only
Y1: 32768 Hz; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
+3V3: C1.1, C2.1, C7.2, C11.2, J2.2, J3.1, J4.1, R7.1, R8.1, R16.1, R17.2, U1.4 (VOUT), U1.5 (FB), U3.4 (VCC), U4.29 (VCC), U4.32 (VCC), U4.33 (VCC), U4.52 (VCC), U4.53 (VCC)
ADC+: C6.1, D1.3 (K), R10.1, R11.2, U3.25 (PC2)
ADC-: C9.1, D2.3 (K), R12.1, R15.2, U3.23 (PC0)
ADC_POWER: C10.1, U2.8 (V+), U3.24 (PC1)
AVCC: C12.2, R16.2, U3.18 (AVCC)
BAT_ADC: R5.1, R6.2, U3.27 (PC4)
BAT_GND: R6.1, U3.28 (PC5)
BAT_VCC: BT1.1 (+), BT2.1 (+), C3.1, R5.2, U1.10 (ILIM0), U1.11 (EN), U1.12 (VIN)
GND: BT1.2 (-), BT2.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.1, C12.1, J1.2, J2.6, J3.4, J4.4, R3.1, R4.2, R11.1, R14.1, R15.1, SW1.2, U1.2 (GND), U1.6 (PFM/PWM), U1.9 (GND), U2.4 (V-), U3.5 (GND), U3.21 (GND), U4.3 (GND), U4.31 (GND), U4.47 (GND), U4.48 (GND), U4.50 (GND), U4.54 (GND), U4.55 (GND), U4.58 (GND), U4.59 (GND), U4.61 (GND), U4.62 (GND)
LA_RX: J4.2, U3.30 (PD0), U4.34 (RXD)
LA_TX: J4.3, U3.31 (PD1), U4.35 (TXD)
LED_CLK: R18.2, U3.3 (PE0)
LED_IDLE: R19.2, U3.6 (PE1)
LED_MSR: R20.2, U3.19 (PE2)
LED_TX: R21.2, U3.22 (PE3)
MCU_MISO: J2.1, J3.2, U3.16 (PB4)
MCU_MOSI: J2.4, J3.3, U3.15 (PB3)
MCU_RESET: C5.1, J2.5, R8.2, SW1.1, U3.29 (~RESET/PC6)
MCU_SCK: J2.3, U3.17 (PB5)
unnamed: D1.1 (A1), D1.2 (A2), U2.7
unnamed: D2.1 (A1), D2.2 (A2), U2.1
unnamed: D3.2 (A), R17.1
unnamed: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), J1.1
unnamed: D4.2 (A), R18.1
unnamed: D5.2 (A), R19.1
unnamed: D6.2 (A), R20.1
unnamed: D7.2 (A), R21.1
unnamed: J101.1, R1.2
unnamed: J102.1, R4.1
unnamed: R1.1, R2.2
unnamed: L1.1, U1.1 (L1)
unnamed: L1.2, U1.3 (L2)
unnamed: R7.2, U1.8 (PG)
unnamed: C4.1, U1.7 (SS)
unnamed: R14.2, U2.3 (+)
unnamed: R12.2, R13.1, U2.2 (-)
unnamed: R9.1, U2.5 (+)
unnamed: R10.2, U2.6 (-)
unnamed: C8.1, U3.20 (AREF)
unnamed: U3.7 (XTAL1/PB6), Y1.1
unnamed: U3.8 (XTAL2/PB7), Y1.2
PROBE: R2.1, R3.2, R9.2, R13.2
RN_RESET: U3.12 (PB0), U4.26 (RSTN)

## Commit log

2023-08-08 first draft
2023-08-09 ignore production file export
2023-08-09 update layout, prepared for production
2023-08-09 ignore lck and MacOS files
2023-08-09 rename project files and clean up
2023-08-09 fix part numbers
2023-08-12 fix project name
2023-08-12 add TME order numbers
2023-08-12 fix TA66 rx and tx
2023-08-19 redesinged for 4 mounting holes
2023-08-19 add OSHW logo
2023-08-19 refine edges
2023-08-19 exclude DRC warnings traces crossing margin
2023-08-20 switch to dual battery holder with adjusted measures
2023-08-20 clean up
2023-08-20 add some datasheets
2023-08-29 add more datasheets
2023-08-29 some refactoring
    - add activate circuit
    - change some parts to JLCPCB basic parts
    - adjusted resistors of LEDs
    - add diode to prevent battery reverse polarization
2023-09-13 hide MH4 silkscreen
2023-09-13 fix Q1 orientation
2023-09-13 switch Q2 to a N-MOSFET and simplify activation circuit
2023-09-13 change Q2 to 2N7002
2023-09-13 increase resistors of emerald LEDs to 1k
2023-09-13 exclude holes and fence terminals from BOM
2023-09-13 bump REV to v0.3
2023-09-14 turn ISP connector
2023-09-26 cleanup
    - move whole power regulator VCC behind actviation circuit
    - switch to battery clamps with options for 18650 and 18500 positions
2023-09-26 bump REV to v.04
2023-09-26 move and turn D1
2023-09-26 update DRC exclusions
2023-09-26 switch battery clamps
2023-10-13 allow easier LA66 firmware update
    - pushing reset also resets LA66 (pulls RST low)
    - optional pin header to bridge PA2/BOOT with RX
2023-10-13 add orientation mark for ISP connector
2023-10-13 adjust diode and battery clip positions
2023-10-13 change D1
2023-10-13 change R5 and R6 to some more common and higher values to reduce measuring current
    this change has been done to all rev0.4 devices manually
2023-10-14 fix GitHub URL
2023-10-14 exclude FLASH pins from BOM
2023-10-14 include LED pins in BOM
2023-10-14 add JLCPCB part number for R3
    but still excluded from BOM
2023-10-14 fix LED pin header position
2023-10-14 hide not populated pin headers from 3D view
2023-10-14 add new 3D models
2023-10-14 exclude additional DRC violations
2023-10-14 update footprint with new 3D model
2023-10-14 archive 3D models to project
    used plugin "Archive 3D models" from https://github.com/MitjaNemec/Archive3DModels
2023-10-15 move probe trace to bottom side
2023-10-15 archive new footprint in project
2023-10-15 remove LA_RESET from button because of reset loop with MCU
2023-10-15 KiCad changes
2023-10-15 globally ignore footprint mismach
2023-10-15 fix DRC exclusions
2023-10-15 extend Flash LA connector with RST and GND
2023-10-15 add another DRC exclusion
2023-10-17 add comment with optional R3 values
2023-10-17 switch default R3 to 5k6 --> 11.8kV and do not exclude
2023-10-17 add comment with R3 options on board
2023-10-19 rename directory
2023-10-19 move KiCad files to subdirectory
2023-10-19 add README
2023-10-22 decrease text size and update positions
2023-10-22 include R1, R2, R4 in BOM
2023-11-22 add order nurmber for R1/R4 and R2
2023-11-22 add frame around LED descriptions
2023-11-22 emphasize and move battery pole markings
2023-11-22 move logo and title text to copper layer, fix DRC
2023-11-22 connector updates
    - move connectors a little to the inside
    - populate ISP connector
2023-11-23 move DEBUG LED connector and update silkscreen
2023-11-24 add positions of unused case screw holes
2023-11-24 move FLASH LA connector away from case screw hole
2023-11-24 move battery clamps to avoid overlapping with case screw holes
2023-11-24 fix DRC
2023-11-24 fix trace width
2023-11-24 bump revision to rev1.0
2024-03-03 fix new line at eof
